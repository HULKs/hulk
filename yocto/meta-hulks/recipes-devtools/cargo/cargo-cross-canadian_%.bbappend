FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Make-it-possible-to-set-the-dynamic-linker.patch"

